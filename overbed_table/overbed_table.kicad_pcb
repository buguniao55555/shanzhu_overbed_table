# Repository buguniao55555/shanzhu_overbed_table

## KiCad design overbed_table/overbed_table.kicad_pcb

Parts:
C1, C3, C4, C7: 1uF; C_0603_1608Metric
C2: 470uF; CP_Elec_10x10.5; not fitted
C5: 100nF; C_0603_1608Metric
C6: 10uF; C_0603_1608Metric
CN2, CN3: KF2EDGRC-5.08-4P; C441238_CONN-TH_4P-P5_08_KF2EDGRC-5_08-4P; LCSC C441238
CN8, CN9, CN10: DLL-5569-2AW; C22365654_CONN-TH_DLL-5569-2AW-GOLD-GR; LCSC C22365654
D1: SMCJ12A; D_SMC
D2: PMEG2010ER; Nexperia_CFP3_SOD-123W
D3: LED; LED_0603_1608Metric
F1, F2, F3: 3557-2; C352820_FUSE-TH_4P-L19_8-W6_7_3557-2; LCSC C352820
H1: LAIL-PZ2.54-4P-L; C54950602_CONN-TH_LAIL-PZ2_54-4P-L; LCSC C54950602
R1, R2, R3, R6, R11, R80: 10k; R_0603_1608Metric
R4, R5: 33; R_0603_1608Metric
SW1, SW2: KH-6X6X6H-STM; C2837532_SW-SMD_4P-L6_0-W6_0-P4_50-LS9_0_KH-6X6X6H-STM; LCSC C2837532
U1: AP2112K-3.3TRG1; C51118_SOT-25-5_L2_9-W1_6-P0_95-LS2_8-BL; LCSC C51118
U2: ESP32-C3-WROOM-02
U3: WAFER-XH254WZ-2A; C7432691_CONN-TH_2P-P2_50_WAFER-XH254WZ-2A; LCSC C7432691
U4, U5, U6: BSMD2920-500-24V; C20539727_F2920; LCSC C20539727
U7: KF7620-7.62-2P; C475104_CONN-TH_P7_62_KF7620-7_62-2P; LCSC C475104
X1: AFA01-S05FCA-00; C262753_FPC-SMD_AFA01-S05FCA-00; LCSC C262753

Connections:
/3V3_5V_转换器/3V3_SIG0: U2.3 (IO4); also elsewhere on the board
/3V3_5V_转换器/3V3_SIG1: U2.5 (IO6); also elsewhere on the board
/3V3_5V_转换器/3V3_SIG2: U2.6 (IO7); also elsewhere on the board
/3V3_5V_转换器/5V_SIG0: X1.5; also elsewhere on the board
/3V3_5V_转换器/5V_SIG1: X1.4; also elsewhere on the board
/3V3_5V_转换器/5V_SIG2: X1.3; also elsewhere on the board
/+3V3: C5.2, C6.2, D2.1 (K), R1.1, R2.1, R3.1, R80.1, U2.1 (3V3), U3.1; also elsewhere on the board
/+5V: X1.1; also elsewhere on the board
/+12V: C2.1, D1.1 (K), D3.2 (A), F1.3, F1.4, F2.3, F2.4, F3.3, F3.4, U4.1, U5.1, U6.1; also elsewhere on the board
/ESP32_BOOT: R2.2, SW2.4 (D), U2.8 (IO9)
/ESP32_D+: H1.3, R5.2
/ESP32_D-: H1.2, R4.2
/ESP32_EN: C1.1, R1.2, SW1.2 (B), U2.2 (EN)
/ESP32_GPIO2: R3.2, U2.16 (IO2)
/ESP32_GPIO8: R80.2, U2.7 (IO8)
/E_STOP: C7.1, R6.1, U2.4 (IO5), U3.2
/GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.2, CN2.4, CN3.4, D1.2 (A), H1.4, R6.2, R11.2, SW1.4 (D), SW2.2 (B), U1.2 (GND), U2.9 (GND), U2.19 (GND), U7.1, X1.2; also elsewhere on the board
/LED1_PWM: U2.18 (IO0); also elsewhere on the board
/LED2_PWM: U2.17 (IO1); also elsewhere on the board
/LED3_PWM: U2.15 (IO3); also elsewhere on the board
/LED灯驱动1/LED_Drain: CN9.1; also elsewhere on the board
/LED灯驱动2/LED_Drain: CN10.1; also elsewhere on the board
/LED灯驱动/LED_Drain: CN8.1; also elsewhere on the board
/RS485_DE: U2.10 (IO10); also elsewhere on the board
/RS485_ESP32/RS485_N: CN2.2, CN3.2; also elsewhere on the board
/RS485_ESP32/RS485_P: CN2.1, CN3.1; also elsewhere on the board
/RS485_ESP32/RS485_RX: U2.11 (IO20/RXD); also elsewhere on the board
/RS485_ESP32/RS485_TX: U2.12 (IO21/TXD); also elsewhere on the board
unnamed: CN2.3, F2.1, F2.2
unnamed: CN3.3, F3.1, F3.2
unnamed: CN8.2, U4.2
unnamed: CN9.2, U5.2
unnamed: CN10.2, U6.2
unnamed: C4.1, D2.2 (A), U1.5 (VOUT)
unnamed: D3.1 (K), R11.1
unnamed: F1.1, F1.2, U7.2
unnamed: C3.2, H1.1, U1.1 (VIN), U1.3 (EN)
unnamed: R4.1, U2.13 (IO18)
unnamed: R5.1, U2.14 (IO19)

Notes on the sheet:
入口电路
急停按钮
LED驱动
烧录端口和5v转3v3 USB供电
BOOT相关GPIO

Parts:
Q4: AON7524; C431195_DFN-8_L3_0-W3_0-P0_65-BL; LCSC C431195
R35: 33; R_0603_1608Metric
R36: 10k; R_0603_1608Metric

Connections:
/GND: Q4.1 (S), Q4.2 (S), Q4.3 (S), R36.2; also elsewhere on the board
/LED1_PWM: R35.2; also elsewhere on the board
/LED灯驱动/LED_Drain: Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D); also elsewhere on the board
unnamed: Q4.4 (G), R35.1, R36.1

Parts of its further copies:
Q5, Q6: AON7524; C431195_DFN-8_L3_0-W3_0-P0_65-BL; LCSC C431195
R37, R78: 33; R_0603_1608Metric
R38, R79: 10k; R_0603_1608Metric

Connections of its further copies:
/GND: Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R38.2, R79.2; also elsewhere on the board
/LED2_PWM: R37.2; also elsewhere on the board
/LED3_PWM: R78.2; also elsewhere on the board
/LED灯驱动1/LED_Drain: Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D); also elsewhere on the board
/LED灯驱动2/LED_Drain: Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D); also elsewhere on the board
unnamed: Q5.4 (G), R37.1, R38.1
unnamed: Q6.4 (G), R78.1, R79.1

Parts:
Q1, Q2, Q3: BSS138; SOT-23
R14, R15, R16, R17, R18, R19: 4.7k; R_0603_1608Metric

Connections:
/3V3_5V_转换器/3V3_SIG0: Q1.2 (S), R14.2; also elsewhere on the board
/3V3_5V_转换器/3V3_SIG1: Q2.2 (S), R15.2; also elsewhere on the board
/3V3_5V_转换器/3V3_SIG2: Q3.2 (S), R16.2; also elsewhere on the board
/3V3_5V_转换器/5V_SIG0: Q1.3 (D), R17.2; also elsewhere on the board
/3V3_5V_转换器/5V_SIG1: Q2.3 (D), R18.2; also elsewhere on the board
/3V3_5V_转换器/5V_SIG2: Q3.3 (D), R19.2; also elsewhere on the board
/+3V3: Q1.1 (G), Q2.1 (G), Q3.1 (G), R14.1, R15.1, R16.1; also elsewhere on the board
/+5V: R17.1, R18.1, R19.1; also elsewhere on the board

Parts:
C8, C9: 10uF; C_0805_2012Metric
C10: 100nF; C_0805_2012Metric
C11, C12, C13: 22uF; C_0805_2012Metric
D4: LED; LED_0603_1608Metric
L1: FXL0630-3R3-M; C167219_IND-SMD_L7_0-W6_6; LCSC C167219
R7: 33.2k; R_0603_1608Metric
R8: 10k; R_0603_1608Metric
R12, R13: 1k; R_0603_1608Metric
TP2: TestPoint; TestPoint_Pad_D2.5mm
U10: TPS562201DDCR; C90061_SOT-23-6_L2_9-W1_6-P0_95-LS2_8-BR; LCSC C90061

Connections:
/+3V3: C11.1, C12.1, C13.1, D4.2 (A), L1.2, R7.2, TP2.1 (1_1); also elsewhere on the board
/+12V: C8.1, C9.1, U10.3 (VIN), U10.5 (EN); also elsewhere on the board
/GND: C8.2, C9.2, C11.2, C12.2, C13.2, R8.1, R12.1, U10.1 (GND); also elsewhere on the board
unnamed: D4.1 (K), R13.2
unnamed: R12.2, R13.1
unnamed: C10.2, L1.1, U10.2 (SW)
unnamed: C10.1, U10.6 (VBST)
unnamed: R7.1, R8.2, U10.4 (VFB)

Parts:
C34: 100nF; C_0603_1608Metric
R26: 10k; R_0603_1608Metric
R27: 120; R_0603_1608Metric; not fitted
R28, R29: 390; R_0603_1608Metric
U15: SP3485EN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/+3V3: C34.1, R28.1, U15.8 (VCC); also elsewhere on the board
/GND: C34.2, R26.2, R29.2, U15.5 (GND); also elsewhere on the board
/RS485_DE: R26.1, U15.2 (~RE), U15.3 (DE); also elsewhere on the board
/RS485_ESP32/RS485_N: R27.2, R29.1, U15.7 (B); also elsewhere on the board
/RS485_ESP32/RS485_P: R27.1, R28.2, U15.6 (A); also elsewhere on the board
/RS485_ESP32/RS485_RX: U15.1 (RO); also elsewhere on the board
/RS485_ESP32/RS485_TX: U15.4 (DI); also elsewhere on the board

Parts:
C14, C15: 10uF; C_0805_2012Metric
C16: 100nF; C_0805_2012Metric
C17, C18: 22uF; C_0805_2012Metric
D5: LED; LED_0603_1608Metric
L2: FXL0630-3R3-M; C167219_IND-SMD_L7_0-W6_6; LCSC C167219
R9: 56.2k; R_0603_1608Metric
R10: 10k; R_0603_1608Metric
R20: 4.7k; R_0603_1608Metric
TP1: TestPoint; TestPoint_Pad_D2.5mm
U11: TPS562201DDCR; C90061_SOT-23-6_L2_9-W1_6-P0_95-LS2_8-BR; LCSC C90061

Connections:
/+5V: C17.1, C18.1, D5.2 (A), L2.2, R9.1, TP1.1 (1_1); also elsewhere on the board
/+12V: C14.1, C15.1, U11.3 (VIN), U11.5 (EN); also elsewhere on the board
/GND: C14.2, C15.2, C17.2, C18.2, R10.2, R20.1, U11.1 (GND); also elsewhere on the board
unnamed: D5.1 (K), R20.2
unnamed: C16.2, L2.1, U11.2 (SW)
unnamed: C16.1, U11.6 (VBST)
unnamed: R9.2, R10.1, U11.4 (VFB)

Board: 2 copper layers, 51.0 x 87.5 mm, 87 parts (2 on the bottom side), 51 nets.

## KiCad design keyboard/keyboard.kicad_pcb

Parts:
C1, C2, C3: 100pF; C_0603_1608Metric
C4: 100uF; CP_Elec_6.3x7.7
C5: 100nF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6: 1N4148W; D_SOD-123
D7: LED; LED_0603_1608Metric
LED1, LED2: FJ5361AH; C18187_LED-SEG-TH_FJ5361AH; LCSC C18187
R1, R2, R3: 10k; R_0603_1608Metric
R4: 4.7k; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12: KH-6X6X6H-STM; C2837532_SW-SMD_4P-L6_0-W6_0-P4_50-LS9_0_KH-6X6X6H-STM; LCSC C2837532
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_D2.0mm
U1: TM1638; C19187_SOIC-28_L17_9-W7_5-P1_27-LS10_3-BL; LCSC C19187
X1: AFA01-S05FCA-00; C262753_FPC-SMD_AFA01-S05FCA-00; LCSC C262753

Connections:
+5V: C4.1, C5.1, D7.2 (A), R1.1, R2.1, R3.1, U1.4 (VDD), U1.15 (VDD), X1.1
/GRID1: LED1.12 (DIG1), U1.24 (GR1)
/GRID2: LED1.9 (DIG2), U1.23 (GR2)
/GRID3: LED1.8 (DIG3), U1.22 (GR3)
/GRID4: LED2.12 (DIG1), U1.21 (GR4)
/GRID5: LED2.9 (DIG2), U1.20 (GR5)
/GRID6: LED2.8 (DIG3), U1.19 (GR6)
/SEG1: D1.2 (A), LED1.11 (A), LED2.11 (A), U1.5 (SEG1/K1)
/SEG2: D2.2 (A), LED1.7 (B), LED2.7 (B), U1.6 (SEG2/K2)
/SEG3: D3.2 (A), LED1.4 (C), LED2.4 (C), U1.7 (SEG3/K3)
/SEG4: D4.2 (A), LED1.2 (D), LED2.2 (D), U1.8 (SEG4/K4)
/SEG5: D5.2 (A), LED1.1 (E), LED2.1 (E), U1.9 (SEG5/K5)
/SEG6: D6.2 (A), LED1.10 (F), LED2.10 (F), U1.10 (SEG6/K6)
/SEG7: LED1.5 (G), LED2.5 (G), U1.11 (SEG7/K7)
/SEG8: LED1.3 (DP), LED2.3 (DP), U1.12 (SEG8/K8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, R4.2, TP4.1 (1_1), U1.18 (GND), U1.25 (GND), X1.2
unnamed: D1.1 (K), SW1.4 (D), SW2.4 (D)
unnamed: D2.1 (K), SW3.4 (D), SW4.4 (D)
unnamed: D3.1 (K), SW5.4 (D), SW6.4 (D)
unnamed: D4.1 (K), SW7.4 (D), SW8.4 (D)
unnamed: D5.1 (K), SW9.4 (D), SW10.4 (D)
unnamed: D6.1 (K), SW11.4 (D), SW12.4 (D)
unnamed: D7.1 (K), R4.1
unnamed: SW1.1 (A), SW3.1 (A), SW5.1 (A), SW7.1 (A), SW9.1 (A), SW11.1 (A), U1.3 (K3)
unnamed: SW2.1 (A), SW4.1 (A), SW6.1 (A), SW8.1 (A), SW10.1 (A), SW12.1 (A), U1.2 (K2)
unnamed: C2.1, R2.2, TP2.1 (1_1), U1.27 (CLK), X1.4
unnamed: C3.1, R3.2, TP3.1 (1_1), U1.26 (DIO), X1.5
unnamed: C1.1, R1.2, TP1.1 (1_1), U1.28 (STB), X1.3

Board: 2 copper layers, 140.5 x 45.8 mm, 36 parts (6 on the bottom side), 28 nets.

## KiCad design side_panel/side_panel.kicad_pcb

Parts:
C1, C2, C3: 100nF; C_0603_1608Metric
C4, C7, C8: 1uF; C_0603_1608Metric
C5, C6: 1nF; C_0603_1608Metric; not fitted
CN1: KF2EDGRC-5.08-4P; C441238_CONN-TH_4P-P5_08_KF2EDGRC-5_08-4P; LCSC C441238
CN2: DLL-5569-6AW; C22365656_CONN-TH_6P-P4_20_C9900016025; LCSC C22365656
D1, D2: LED; LED_0603_1608Metric
H1: LAIL-PZ2.54-6P-L; C54950607_CONN-TH_LAIL-PZ2_54-6P-L; LCSC C54950607
R1, R5, R6, R11, R12, R13: 10k; R_0603_1608Metric
R2: 0; R_0603_1608Metric; not fitted
R3, R4, R9, R10: 100; R_0603_1608Metric
R7, R8: 10k; R_0603_1608Metric; not fitted
R14, R15: 1k; R_0603_1608Metric
SW1, SW2: KH-6X6X6H-STM; C2837532_SW-SMD_4P-L6_0-W6_0-P4_50-LS9_0_KH-6X6X6H-STM; LCSC C2837532
U1, U2: KF128-5.08-2P; C474952_CONN-TH_P5_08_KF128-5_08-2P; LCSC C474952
U3: PY32F030K28U6TR; C3018718_QFN-32_L5_0-W5_0-P0_50-TL-EP3_5; LCSC C3018718
U4: WAFER-XH254WZ-4A; C7432693_CONN-TH_4P-P2_50_WAFER-XH254WZ-4A; LCSC C7432693
U5, U6: WAFER-XH254WZ-2A; C7432691_CONN-TH_2P-P2_50_WAFER-XH254WZ-2A; LCSC C7432691
X1: AFA01-S05FCA-00; C262753_FPC-SMD_AFA01-S05FCA-00; LCSC C262753

Connections:
+3V3: C2.2, C4.2, CN2.1, D2.2 (A), H1.1, R1.1, R5.1, R7.1, R8.1, SW2.2 (B), U3.1 (VCC), U4.1, U5.1, U6.1, X1.4; also elsewhere on the board
+12V: CN1.3, D1.2 (A); also elsewhere on the board
/BOARD_ID: R1.2, R2.1, U3.6 (PA0)
/BOOT: C3.1, R6.1, SW2.4 (D), U3.31 (PF4-BOOT0)
/EXT_ENC_A: C6.1, R8.2, R9.1, U3.3 (OSCOUT-PF1)
/EXT_ENC_B: C5.1, R7.2, R10.1, U3.2 (OSCIN-PF0)
/ISP_RX: H1.5, U3.25 (PA15)
/MOTOR_BI: U3.18 (PA8); also elsewhere on the board
/MOTOR_ENC_A: R3.1, U3.14 (PB0)
/MOTOR_ENC_B: R4.2, U3.13 (PA7)
/MOTOR_FI: U3.17 (PB2); also elsewhere on the board
/MOTOR_OUT1: CN2.4; also elsewhere on the board
/MOTOR_OUT2: CN2.6; also elsewhere on the board
/PUSH_BUTTON_1: C8.1, R12.1, U3.5 (PF3), U6.2
/PUSH_BUTTON_2: C7.1, R11.1, U3.7 (PA1), U5.2
/RS485_A: CN1.1; also elsewhere on the board
/RS485_B: CN1.2; also elsewhere on the board
/RS485_PY32/RS485_DE: U3.22 (PA12); also elsewhere on the board
/RS485_PY32/RS485_RX: U3.21 (PA11); also elsewhere on the board
/RS485_PY32/RS485_TX: U3.20 (PA10-OSC32IN); also elsewhere on the board
/RST: C1.1, H1.6, R5.2, SW1.2 (B), U3.4 (PF2-NRST)
/SCL: U3.11 (PA5), X1.2; also elsewhere on the board
/SDA: U3.12 (PA6), X1.3; also elsewhere on the board
/STEPPER_OA1: U1.1; also elsewhere on the board
/STEPPER_OA2: U1.2; also elsewhere on the board
/STEPPER_OB1: U2.1; also elsewhere on the board
/STEPPER_OB2: U2.2; also elsewhere on the board
/SWCLK: H1.4, U3.24 (PA14)
/SWDIO: H1.3, U3.23 (PA13)
/TMC_DIAG: U3.26 (PB3); also elsewhere on the board
/TMC_DIR: U3.29 (PB6); also elsewhere on the board
/TMC_EN: U3.28 (PB5); also elsewhere on the board
/TMC_STEP: U3.30 (PB7); also elsewhere on the board
/TMC_UART: U3.27 (PB4); also elsewhere on the board
/TOF_XSHUT: U3.10 (PA4), X1.1; also elsewhere on the board
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, CN1.4, CN2.3, H1.2, R2.2, R6.2, R11.2, R12.2, R13.2, R15.2, SW1.4 (D), U3.16 (VSS), U3.33 (VSS), U4.2, X1.5; also elsewhere on the board
unnamed: CN2.2, R4.1
unnamed: CN2.5, R3.2
unnamed: D1.1 (K), R13.1
unnamed: D2.1 (K), R14.1
unnamed: R9.2, U4.3
unnamed: R10.2, U4.4
unnamed: R14.2, R15.1

Notes on the sheet:
电机输出接口
TOF
升降电机驱动
12V-3V3
步进电机接口
左右板识别电阻
SWD烧录端口
外部编码器
电源/RS485输入接口
电源指示灯
RST/BOOT电路
步进电机驱动
外部按钮
